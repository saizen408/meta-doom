# We want to manually start an x-session when doom is started
SYSTEMD_AUTO_ENABLE = "disable"
